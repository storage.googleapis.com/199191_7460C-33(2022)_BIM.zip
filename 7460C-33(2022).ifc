Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-28T13:04:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 28 13:04:36 2022 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\{DE03BA35-85AE-4864-ACC8-36A660B59FC7}\ifc * Database version: 5507 * Database creation date: Mon Nov 28 13:04:36 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 28 13:04:36 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 28 13:04:36 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7460C-33 Shower faucet, 7460C-33(2022):7460C-33 Shower faucet:429852
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 107.628 mm; NominalHeight: 70.4 mm; NominalWidth: 290 mm
Type - General - Author: BIMStone; BIMObjectName: 7460C-33(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 23/11/2022
Type - Green Building Properties - EAN Number: 6414150100796; EN Standard: EN 1111; ETIM Class Number: EC011329 Shower mixing tap; LVI Number: 6310896; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4202685; RSK Number: 8350002; Sales Package dimensions (LxWxH): 294 x 164 x 83; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/7460C-33; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/7460C-33; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/7460C-33
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7460C-33; 3D View: https://static.oras.com/AR/7460C-33; Catalog Drawing URL: http://static.oras.com/catdrw/7460C-33; Dimension Drawing URL: http://static.oras.com/dimdrw/7460C-33; FDV Document URL: http://www.oras.com/datasheet/7460C-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7460C-33; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7460C-33; Interactive AR View URL: https://static.oras.com/AR/7460C-33; Long Marketing: Thermostatic shower faucet. Temperature handle equipped with safety stop at 38°C. Volume handle with Eco Flow control. The faucet includes litter filters and non-return valves.; Manufacturer: Oras; Market: International;Norway; Mobile Product Information URL: http://mpi.oras.com/7460C-33; Model: 7460C-33 Shower faucet; Name_en: 7460C-33 Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7460C-33; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7460C-33; Product URL: http://static.oras.com/7460C-33; Spare-Part Information URL: http://static.oras.com/sp/7460C-33; Technical DataSheet URL: http://www.oras.com/datasheet/7460C-33/en; Type Name: 7460C-33 Shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Fine Textured - Black
Type - Mechanical - Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread;Cover plate(s); Connection Size: G3/4; Eco Flow At 300kPa: 0.00670979 m3/s; Flow Rate At 300kPa: 0.00953496 m3/s; Installation Type: Wall mounted; Installation Width: cc150 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;;Non-return valve(s);Litter filter(s); Pressure Loss With Flow 02ls: 165000 Pa; Shower Parts: Eco flow control; Surface treatment: Matt black; Temperature Adjustments: Safety stop against scalding at 38°C;Temperature preset fixable; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7460C-33(2022); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7460C-33; Name: 7460C-33 Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 290x110x70 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7460C-33; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7460C-33 Shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0617732 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00221394 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7460C-33(2022): 7460C-33 Shower faucet; Family and Type: 7460C-33(2022): 7460C-33 Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7460C-33(2022): 7460C-33 Shower faucet; Type Id: 7460C-33(2022): 7460C-33 Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
